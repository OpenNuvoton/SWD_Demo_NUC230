# Keil uVision project SWDDemo_M2351NS.uvproj, settings and files
target SWDDemo_M2351NS (ARM-ADS)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SWDDemo_M2351NS
  AfterMake: fromelf --bin ".\obj\M2351NS\@L.axf" --output ".\obj\M2351NS\@L.bin"
  AfterMake: fromelf --text -c ".\obj\M2351NS\@L.axf" --output ".\obj\M2351NS\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __TARGET_M2351_NS__
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group User
    ../: main.c swd_host.c DAP.c SW_DP.c target_flash.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c
  group M2351NS
    ../M2351NS/: flash_blob.c LoaderImage.s target.c target_reset.c
